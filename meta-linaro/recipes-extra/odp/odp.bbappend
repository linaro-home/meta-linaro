
SRC_URI += "file://0001-implement-odp_timer_disarm_all.patch"
CFLAGS += "-fPIC"
