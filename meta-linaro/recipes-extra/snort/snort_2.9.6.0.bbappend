PR = "r2"
SRC_URI += "file://0001-add-dependancy-for-lrt.patch;striplevel=2"
LDFLAGS += "-lrt"
